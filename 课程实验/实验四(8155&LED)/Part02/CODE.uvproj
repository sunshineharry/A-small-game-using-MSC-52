# Keil uVision project CODE.uvproj, settings and files
target CODE (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CODE +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: 8155.c main.c
  group dependence
    ./dependence/: 8155.H 8155_func.h
