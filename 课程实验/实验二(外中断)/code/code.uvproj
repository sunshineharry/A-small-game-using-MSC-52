# Keil uVision project code.uvproj, settings and files
target code (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src;.\dependence\build-in;.\dependence\build-in\toolchain
  group src
    ./src/: interrupt.c main.c tasks.c
  group dependence
    ./dependence/: interrupt_func.h
