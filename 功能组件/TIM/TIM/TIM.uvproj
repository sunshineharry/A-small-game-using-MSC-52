# Keil uVision project TIM.uvproj, settings and files
target TIM (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TIM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: main.c
  group dependence
    ./dependence/: RTE_Components.h
