# Keil uVision project code.uvproj, settings and files
target code (MCS-51)
  device: AT89C52 Atmel
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: main.c
  group dependence
    ./dependence/: interrupt.h RTE_Components.h
