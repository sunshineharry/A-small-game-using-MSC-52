# Keil uVision project code.uvproj, settings and files
target code (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: keyboard.c main.c
  group dependence
    ./dependence/: keyboard.h keyboard_func.h RTE_Components.h STARTUP.A51
