# Keil uVision project test_led.uvproj, settings and files
target test_led (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test_led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src;.\dependence\build-in;.\dependence\build-in\STD
  group src
    ./src/: main.c
  group dependence
    ./dependence/: RTE_Components.h
