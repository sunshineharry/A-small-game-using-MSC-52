# Keil uVision project code.uvproj, settings and files
target code (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code +hex
  c flags: Optimize=8
  c include: .\dependence;.\src
  group src
    ./src/: interrupt.c keyboard.c LCD.c main.c random.c tasks.c
  group dependence
    ./dependence/: interrupt_func.h keyboard.h keyboard_func.h LCD.h LCD_func.h random_func.h
